# Keil uVision project hello_world.uvprojx, settings and files
target hello_world debug (ARM-ADS)
  device: MKL46Z256VLL4 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: hello_world.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKL46Z256VLL4, FRDM_KL46Z, FREEDOM, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../..;..
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL46Z256xxx4_flash.scf
  group source
    ../: hello_world.c
  group doc
    ../: readme.txt
target hello_world release (ARM-ADS)
  device: MKL46Z256VLL4 NXP
  cpu: CPUTYPE("Cortex-M0+")
  output: hello_world.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL46Z256VLL4, FRDM_KL46Z, FREEDOM, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: as above
  c include: ../../..;..
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL46Z256xxx4_flash.scf
software components: Device:Startup 1.0.0, Device:SDK Drivers:clock 2.1.0, Device:Startup 1.0.0, Device:SDK Drivers:port 2.0.2, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:assert 1.0.0, CMSIS:CORE 5.0.1, Device:SDK Drivers:uart 2.1.5, Device:SDK Drivers:smc 2.0.3, Device:SDK Drivers:common 2.0.0, Device:SDK Drivers:i2c 2.0.5, Board Support:SDK Project Template:project_template 1.0.0, Device:SDK Drivers:flash 3.0.0, Device:SDK Drivers:gpio 2.2.1, Device:SDK Drivers:lpsci 2.0.4
